# Keil uVision project HelloLCD.uvprojx, settings and files
target HelloLCD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HelloLCD
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L072xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32l0xx_hal_msp.c main.c stm32l0xx_it.c lcd_drv_hd44780.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Application/MDK-ARM
    ./: startup_stm32l072xx.s
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_pwr.c stm32l0xx_hal_gpio.c stm32l0xx_hal_cortex.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_dma.c
software components: CMSIS:CORE 5.0.2
